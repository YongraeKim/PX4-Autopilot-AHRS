## src/modules/microstrain_ahrs/Kconfig
```kconfig
menuconfig MODULES_MICROSTRAIN_AHRS
	bool "microstrain_ahrs"
	default n
	---help---
		Enable support for microstrain_ahrs
```
